# Keil uVision project P_Wistec_HairBrush_V10.uvproj, settings and files
target P_Wistec_HairBrush_V10 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC029LAN Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: P_Wistec_HairBrush_V10(260819)
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC029xAN\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
  group User
    ../: main.c key.c keyexec.c function.c pub_ram.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c i2c.c sys.c uart.c acmp.c adc.c ebi.c fmc.c gpio.c pwm.c spi.c timer.c wdt.c wwdt.c
